# Repository kyleterry/spacetime-keyboard

File README.md:

# Spacetime Keyboard

The Spacetime is a ~36% split ortho-linear keyboard based on
the Half n Half, ErgoDox and Helix. It has a tripple thumb cluster
and an optional palm key. The palm key can be broken off and not
used at all if you don't want it.

Currently being shipped some prototypes and I will probably have
some bugs to work out. After that I will need to add more silk screen
and I need to create jumper pads to support the OLED that can go over
the microcontroller.

## KiCad design ergl.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25: D; D_axial
J1, J7: CONN_02; 1X02
J2, J8: CONN_01; 1X01
J3: AUDIO_JACK_TRRSSMD_RA; AUDIO_JACK_3.5MM_TRRS_SMD_RA
J4: CONN_03; 1X03
J5: 0548190519; USB_Mini_B_Female_548190519; MPN 0548190519; Digi-Key_PN WM17115-ND
J6: CONN_04; 1X04
K1, K2, K3, K4, K5, K6, K7, K8, K9, K10, K11, K12, K13, K14, K15, K16, K17, K18, K19, K20, K21, K22, K23: KEYSW; MX_PCB_100H_DUAL_HOLE
K24, K25: KEYSW; MX_PCB_200V_DUAL_HOLES
SW1: RESET BTN; Switch_Tactile_SMD_4.5x4.5mm_TL3315NF160Q
U1: ProMicro

Connections:
/col0: K1.1, K8.1, K15.1, K22.1, U1.20 (F4)
/col1: K2.1, K9.1, K16.1, U1.19 (F5)
/col2: K3.1, K10.1, K17.1, U1.18 (F6)
/col3: K4.1, K11.1, K18.1, U1.17 (F7)
/col4: K5.1, K12.1, K19.1, K23.1, U1.16 (B1)
/col5: K6.1, K13.1, K20.1, K24.1, U1.15 (B3)
/col6: K7.1, K14.1, K21.1, K25.1, U1.14 (B2)
/row0: D1.1, D2.1, D3.1, D4.1, D5.1, D6.1, D7.1, U1.7 (D4)
/row1: D8.1, D9.1, D10.1, D11.1, D12.1, D13.1, D14.1, U1.8 (C6)
/row2: D15.1, D16.1, D17.1, D18.1, D19.1, D20.1, D21.1, U1.9 (D7)
/row3: D22.1, D23.1, D24.1, D25.1, U1.10 (E6)
/serial0: J3.TIP, U1.6 (SDA); also elsewhere on the board
unnamed: D1.2, K1.2
unnamed: D2.2, K2.2
unnamed: D3.2, K3.2
unnamed: D4.2, K4.2
unnamed: D5.2, K5.2
unnamed: D6.2, K6.2
unnamed: D7.2, K7.2
unnamed: D8.2, K8.2
unnamed: D9.2, K9.2
unnamed: D10.2, K10.2
unnamed: D11.2, K11.2
unnamed: D12.2, K12.2
unnamed: D13.2, K13.2
unnamed: D14.2, K14.2
unnamed: D15.2, K15.2
unnamed: D16.2, K16.2
unnamed: D17.2, K17.2
unnamed: D18.2, K18.2
unnamed: D19.2, K19.2
unnamed: D20.2, K20.2
unnamed: D21.2, K21.2
unnamed: D22.2, K22.2
unnamed: D23.2, K23.2
unnamed: D24.2, K24.2
unnamed: D25.2, K25.2
unnamed 37: J1.2, SW1.1, U1.22 (RST); also elsewhere on the board
unnamed: J4.1, U1.3 (GND), U1.4 (GND)
unnamed: J4.2, U1.2 (RX)
unnamed: J4.3, U1.1 (TX)
unnamed: J5.1, J6.2
unnamed: J5.3, J6.4
unnamed: J5.4, J6.3
unnamed: J7.1, U1.12 (B5)
unnamed: J7.2, U1.11 (B4)
unnamed: J8.1, U1.13 (B6)
VCC: J3.EART (EARTH), U1.21 (VCC); also elsewhere on the board

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
Board: 2 copper layers, 160.9 x 115.4 mm, 62 parts (2 on the bottom side), 49 nets.

Other parts of the board:
J3#2: TRRS; AUDIO_JACK_3.5MM_TRRS_SMD_RA
RST BTN: RESET BTN; Switch_Tactile_SMD_4.5x4.5mm_TL3315NF160Q
RST BTN#2: RESET BTN; Switch_Tactile_SMD_4.5x4.5mm_TL3315NF160Q

Their connections:
/serial0: J3#2.TIP; also elsewhere on the board
unnamed 37: RST BTN.1, RST BTN#2.1; also elsewhere on the board
VCC: J3#2.EART; also elsewhere on the board

## Commit log

2019-05-10 pushing up prototype PCB
2019-05-18 pushing up the start to rev2
